# Keil uVision project stm32f407zgt6-gataway.uvprojx, settings and files
target stm32f407zgt6-gataway (6230000::V6.23::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f407zgt6-gataway +hex
  AfterMake: D:\Code_Project\Stm32CubeMx_Proj\stm32f407zgt6-gataway\MDK-ARM\keil-build-viewer.exe
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,CO_CONFIG_SDO_CLI=3,CO_CONFIG_FIFO=1
  c misc: -Wno-invalid-source-encoding -fno-short-wchar -fshort-enums
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../3rdLib/emWin/Config;../3rdLib/emWin/GUI_X;../3rdLib/emWin/include;../BSP/BSP_LCD;../BSP/BSP_LCDTouch;../BSP/BSP_SRAM;../BSP/BSP_Timer;../LWIP/App;../LWIP/Target;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/BSP/Components/lan8742;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/compat/posix;../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/LwIP/system/arch;../BSP/BSP_ETH;../BSP/BSP_CAN;../3rdLib/CANopen/CANopenNode;../3rdLib/CANopen/CANopenNode_STM32;../../../emWin_AppWizard_Proj/V636/gateway/Source/CustomCode;../../../emWin_AppWizard_Proj/V636/gateway/Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group emwin/GUI_X
    ../3rdLib/emWin/GUI_X/: GUI_X.c
  group emwin/Config
    ../3rdLib/emWin/Config/: GUIConf.c GUIConf.h GUIDRV_Template.c GUIDRV_Template.h LCDConf.c LCDConf.h
  group emwin/Lib
    ../3rdLib/emWin/GUILib/: GUI_CM4F_L.lib libGUI_v7m_OS0.a
  group emwin/APPwizard_Demo
    ../../../emWin_AppWizard_Proj/V636/gateway/Source/: APPW_MainTask.c
  group emwin/CustomCode
    ../../../emWin_AppWizard_Proj/V636/gateway/Source/CustomCode/: Application.c Application.h ID_SCREEN_00_Slots.c ID_SCREEN_01_Slots.c ID_SCREEN_02_Slots.c
  group emwin/Generated
    ../../../emWin_AppWizard_Proj/V636/gateway/Source/Generated/: APPWConf.c ID_SCREEN_00.c ID_SCREEN_00.h ID_SCREEN_01.c ID_SCREEN_01.h Resource.c Resource.h ID_SCREEN_02.c
  group emwin/Resource
    ../../../emWin_AppWizard_Proj/V636/gateway/Resource/Font/: _24_Normal_EXT_AA4.c
    ../../../emWin_AppWizard_Proj/V636/gateway/Resource/Image/: bk.c net.c dac.c music.c exit.c
    ../../../emWin_AppWizard_Proj/V636/gateway/Resource/Text/: APPW_Language_0.c APPW_Pattern.c
  group emwin/DSO_Demo
    ../3rdLib/emWin/emWinTask/: DSO_AdcDlg.c DSO_AmplitudeDlg.c DSO_DacDlg.c DSO_DrawBakFrame.c DSO_DrawCursorH.c DSO_DrawCursorV.c DSO_FirFilter_Step1KHz.c DSO_FirFilter_Step10KHz.c DSO_FirFilter_Step100KHz.c DSO_Init.c DSO_MathDlg.c DSO_MeasureDlg.c DSO_MultiMeter.c DSO_ScaleDlg.c DSO_SettingDlg.c DSO_Status1Dlg.c DSO_Status2Dlg.c DSO_SysInfoDlg.c DSO_WaveProcess.c DSOV_MainTask.c MainTask.c
  group emwin/Demo
    ../3rdLib/emWin/emWinDemo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group BSP/SRAM
    ../BSP/BSP_SRAM/: bsp_sram.c bsp_sram.h bsp_sram_port.c bsp_sram_port.h bsp_sram_test.c bsp_sram_test.h malloc.c malloc.h XMRAM.h XMRAM.lib
  group BSP/LCD
    ../BSP/BSP_LCD/: bsp_lcd.c bsp_lcd.h bsp_lcd_port.c bsp_lcd_port.h bsp_lcd_test.c bsp_lcd_test.h lcd_nt35510.c lcd_nt35510.h
  group BSP/LCDTouch
    ../BSP/BSP_LCDTouch/: bsp_touch_port.c bsp_touch_port.h gt9xxx.c gt9xxx.h test_bsp_touch.c test_bsp_touch.h
  group BSP/Timer
    ../BSP/BSP_Timer/: bsp_timer.c bsp_timer.h
  group BSP/ETH
    ../BSP/BSP_ETH/: app_mqtt.c app_mqtt.h bsp_eth.c
  group BSP/CAN
    ../BSP/BSP_CAN/: bsp_can.c bsp_can.h bsp_can_port.c bsp_can_port.h bsp_can_test.c bsp_can_test.h
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group CANopen
    ../3rdLib/CANopen/CANopenNode/: CANopen.c
  group CANopen/301
    ../3rdLib/CANopen/CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c CO_config.h
  group CANopen/303
    ../3rdLib/CANopen/CANopenNode/303/: CO_LEDs.c
  group CANopen/305
    ../3rdLib/CANopen/CANopenNode/305/: CO_LSSslave.c
  group CANopen/STM32
    ../3rdLib/CANopen/CANopenNode_STM32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c
  group app_CAN
    ../BSP/BSP_CAN/: app_CAN.c app_CAN.h
target use AC5-Complier (5060750::V5.06 update 6 (build 750)::.\ARMCC5)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: as above
  output: stm32f407zgt6-gataway +hex
  AfterMake: as above
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,CO_CONFIG_SDO_CLI=3,CO_CONFIG_FIFO=1,USE_AC5
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../3rdLib/emWin/Config;../3rdLib/emWin/GUI_X;../3rdLib/emWin/emWinDemo;../3rdLib/emWin/include;../BSP/BSP_LCD;../BSP/BSP_LCDTouch;../BSP/BSP_SRAM;../BSP/BSP_Timer;../LWIP/App;../LWIP/Target;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/BSP/Components/lan8742;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/compat/posix;../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/LwIP/system/arch;../BSP/BSP_ETH;../BSP/BSP_CAN;../3rdLib/CANopen/CANopenNode;../3rdLib/CANopen/CANopenNode_STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
software components: CMSIS:CORE 6.1.1
